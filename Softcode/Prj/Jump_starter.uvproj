# Keil uVision project Jump_starter.uvproj, settings and files
target CP010 (MCS-51)
  device: MS51EC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: Jump_starter +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc;..\Src\App;..\Src\Comm;..\Src\Drv
  group App
    ../Src/App/: main.c jump_star.c
  group Drv
    ../Src/Drv/: digital_lcd.c led.c app_timer.c PUTCHAR.C app_uart.c app_adc.c
  group Library
    ../Library/StdDriver/src/: sys.c uart.c adc.c delay.c
  group Startup
    ../Library/Startup/Keil/: STARTUP.A51
